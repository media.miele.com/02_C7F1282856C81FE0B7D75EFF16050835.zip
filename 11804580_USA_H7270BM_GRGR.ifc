Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 1c788534-9861-40b0-964f-d3c31417cf8d, NumberOfSaves: 1]
File name: 0001
Time: 2025-12-15T16:34:26+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11804580_USA_H7270BM_GRGR:22727036_USA_11804580_H7270BM_GRGR, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_GRGR, <Unnamed>, z_Miele_Design_Glass Black, z_Miele_Design_Zinc_Steel, z_Miele_Connection_Electric
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 757 mm; Height: 479 mm; Depth: 573 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 22727036_USA_11804580_H7270BM_GRGR; sets with these values: 2
